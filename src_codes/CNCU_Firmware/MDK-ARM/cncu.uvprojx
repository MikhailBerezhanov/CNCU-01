# Keil uVision project cncu.uvprojx, settings and files
target F407VE_Ethernet (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: cncu
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --diag_suppress 177
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Middlewares/Third_Party/FATFS/inc;../Drivers/CNCU/inc;../Drivers/SD_FAT_RTOS_Driver
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: stm32f4xx_it.c main.c lwip.c ethernetif.c MK_Init.c Retarget.c fs.c fsdata.c dbgmsg.c hhtpserver.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_eth.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c timers.c event_groups.c tasks.c list.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: inet6.c nd6.c ip6.c dhcp6.c ip6_frag.c mld6.c icmp6.c ethip6.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c netifapi.c sockets.c api_lib.c api_msg.c netbuf.c netdb.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: upap.c fsm.c utils.c chap_ms.c eap.c ccp.c pppcrypt.c chap-md5.c pppos.c vj.c multilink.c auth.c ipcp.c ipv6cp.c mppe.c magic.c lcp.c demand.c eui64.c ecp.c pppapi.c pppoe.c chap-new.c pppol2tp.c ppp.c
    ../Middlewares/Third_Party/LwIP/src/core/: raw.c timeouts.c init.c tcp_in.c netif.c stats.c memp.c tcp_out.c dns.c pbuf.c tcp.c sys.c def.c inet_chksum.c ip.c udp.c mem.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c ip4.c ip4_frag.c dhcp.c autoip.c etharp.c ip4_addr.c igmp.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Drivers/CNCU
    ../Drivers/CNCU/src/: can.c dswitch.c flash.c gtimer.c i2c.c leds.c m95_eeprom.c rs232.c rtc.c spi.c uart.c buzz.c
  group Drivers/SD_FAT_RTOS
    ../Drivers/SD_FAT_RTOS_Driver/: bsp_driver_sd.c diskio.c ff.c ff_gen_drv.c sd_diskio.c syscall.c sdcard.c unicode.c
software components: CMSIS:CORE 4.3.0
